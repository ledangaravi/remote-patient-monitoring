# Repository ledangaravi/remote-patient-monitoring

File README.md:

# Patient24

Welcome to the Patient24 Github Repository. To access detailed documentation about the project, please [go to the wiki](https://github.com/ledangaravi/remote-patient-monitoring/wiki).

## About
Patient24 brings together newly released sensors and state-of-the-art self-charging technology to provide next generation remote patient monitoring.

The Patient24 solution consists of a wearable device accompanied by an Android and an iOS application. [Watch the video](https://www.youtube.com/watch?v=plrVBWvTG4c) below to learn more.

## Contact
- For all enquiries do not hesitate to [contact us via email](mailto:jf1116@ic.ac.uk).

## KiCad design CAD/HealthMonitor.kicad_pcb

Parts:
J1: BAT_T; PinHeader_1x01_P1.27mm_Vertical
J2: TEG+; PinHeader_1x01_P1.27mm_Vertical
J3: TEG-; PinHeader_1x01_P1.27mm_Vertical
J4: BAT-; PinHeader_1x01_P1.27mm_Vertical
J5: BAT+; PinHeader_1x01_P1.27mm_Vertical
J8, J22: VCC; PinHeader_1x01_P1.27mm_Vertical
J9, J23: GND; PinHeader_1x01_P1.27mm_Vertical
J10, J20: SDA; PinHeader_1x01_P1.27mm_Vertical
J11, J21: SCL; PinHeader_1x01_P1.27mm_Vertical
J12, J25: DIS_SW; PinHeader_1x01_P1.27mm_Vertical
J13, J24: BAT_CHRG; PinHeader_1x01_P1.27mm_Vertical
J14: USBDP; PinHeader_1x01_P1.27mm_Vertical
J15: USBDM; PinHeader_1x01_P1.27mm_Vertical
J16: USB_V; PinHeader_1x01_P1.27mm_Vertical
J17: VBUS; PinHeader_1x01_P1.27mm_Vertical
J18: D+; PinHeader_1x01_P1.27mm_Vertical
J19: D-; PinHeader_1x01_P1.27mm_Vertical

Connections:
+3V3: J8.1, J22.1; also elsewhere on the board
/BAT_CHRG: J13.1, J24.1; also elsewhere on the board
/DIS_SW: J12.1, J25.1; also elsewhere on the board
/SCL: J11.1, J21.1; also elsewhere on the board
/SDA: J10.1, J20.1; also elsewhere on the board
/power/BAT+: J5.1; also elsewhere on the board
/power/BAT_T: J1.1; also elsewhere on the board
/power/TEG+: J2.1; also elsewhere on the board
/power/USB_VBUS: J16.1, J17.1; also elsewhere on the board
/programmer/D+: J14.1, J18.1; also elsewhere on the board
/programmer/D-: J15.1, J19.1; also elsewhere on the board
GND: J3.1, J4.1, J9.1, J23.1; also elsewhere on the board

Parts:
C1: 0.1u; C_0402_1005Metric
C2, C3: 10u; C_0402_1005Metric
C4: 10n; C_0402_1005Metric
C5, C8, C24, C25, C28: 1u; C_0402_1005Metric
C6: 4.7u; C_0402_1005Metric
FB1: Ferrite_Bead; L_0402_1005Metric
J6: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Amphenol_12401610E4-2A_CircularHoles
J26: Conn_01x01_Male; PinHeader_1x01_P1.27mm_Vertical
L1: 22u; L_0805_2012Metric
R1, R3: 4M; R_0402_1005Metric
R2: 55.6k; R_0402_1005Metric
R4: 6.49M; R_0402_1005Metric
R5: 3.57M; R_0402_1005Metric
R6: 1M; R_0402_1005Metric
R7: 2M; R_0402_1005Metric
R8: 3.3k; R_0402_1005Metric
R9, R10, R11, R35: 10k; R_0402_1005Metric
R12, R13: 5M; R_0402_1005Metric
R14: 3.01M; R_0402_1005Metric
R15: 6.98M; R_0402_1005Metric
R16, R19: 3.32M; R_0402_1005Metric
R17, R21: 6.65M; R_0402_1005Metric
R18: 1.07M; R_0402_1005Metric
R20: 2.4k; R_0402_1005Metric
R22: 412k; R_0402_1005Metric
R37: 0; R_0402_1005Metric
U1: MAX17048G+T10; MAX17048G+
U2: ADP5092ACPZ-1-R7
U3: LTC4079IDD-PBF
U4, U14: LD39015M33R; SOT-23-5
U13: ADG884BRMZ

Connections:
+3V3: R10.1, R11.1, R20.1, U2.23 (REG_D1), U2.24 (REG_D0), U13.3 (D1); also elsewhere on the board
/BAT_CHRG: R20.2, U3.7 (*CHRG); also elsewhere on the board
/DIS_SW: U2.22 (DIS_SW); also elsewhere on the board
/SCL: R10.2, U1.7 (SCL); also elsewhere on the board
/SDA: R11.2, U1.8 (SDA); also elsewhere on the board
/power/BAT+: C1.2, R35.2, R37.2, U1.2 (CELL), U1.3 (VDD), U13.9 (D2); also elsewhere on the board
/power/BAT_EH: U2.17 (BAT), U13.7 (S2B)
/power/BAT_T: R9.2, U3.5 (NTC); also elsewhere on the board
/power/BAT_USB: R18.2, U3.10 (BAT), U13.10 (S2A)
/power/B_CONN: R6.2, R7.1, U13.4 (IN1), U13.8 (IN2)
/power/EH_3v3: C3.1, U2.14 (REG_OUT), U2.15 (REF_FB), U13.5 (S1B)
/power/PGOOD: U2.19 (PGOOD)
/power/REF: R4.2, R13.1, R15.1, R17.1, R21.1, U2.1 (REF)
/power/REG_GOOD: U2.11 (REG_GOOD)
/power/TEG+: C2.1, L1.2, R3.2, U2.10 (VIN); also elsewhere on the board
/power/USB_3v3: C25.1, U4.5 (OUT), U13.2 (S1A)
/power/USB_VBUS: C5.1, C24.1, J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS), R6.1, U3.1 (IN), U3.2 (EN), U4.1 (IN), U4.3 (EN); also elsewhere on the board
/programmer/D+: J6.A6 (D+); also elsewhere on the board
/programmer/D-: J6.A7 (D-); also elsewhere on the board
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.1, C8.2, C24.2, C25.2, C28.2, FB1.2, J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), R1.1, R2.2, R5.1, R7.2, R8.2, R12.1, R14.1, R16.1, R19.1, U1.1 (CTG), U1.4 (GND), U1.6 (QSTRT), U1.9 (EPAD), U2.7 (AGND), U2.12 (PGND), U2.21 (MINOP), U2.25 (EPGND), U3.6 (TIMER), U3.11 (GND), U4.2 (GND), U13.6 (GND), U14.2 (GND); also elsewhere on the board
unnamed: C4.1, U2.8 (CBP)
unnamed: C6.2, U2.16 (SYS)
unnamed: C8.1, R37.1, U14.1 (IN), U14.3 (EN)
unnamed: C28.1, J26.1, U14.5 (OUT)
unnamed: FB1.1, J6.S1 (SHIELD)
unnamed: L1.1, U2.13 (SW)
unnamed: R1.2, R3.1, U2.9 (MPPT)
unnamed: R2.1, U2.20 (VID)
unnamed: R4.1, R5.2, U2.4 (TERM)
unnamed: R8.1, U3.3 (PROG)
unnamed: R9.1, U3.4 (NTCBIAS)
unnamed: R12.2, R13.2, U2.3 (SETBK)
unnamed: R14.2, R15.2, U2.6 (SETHYST)
unnamed: R16.2, R17.2, U2.5 (SETPG)
unnamed: R18.1, R22.2, U3.9 (FB)
unnamed: R19.2, R21.2, U2.2 (SETSD)
unnamed: R22.1, U3.8 (FBG)
unnamed: R35.1, U13.1 (VDD)

Parts:
C7: 1u; C_0402_1005Metric
D1: LED_ir; D_0603_1608Metric
D2, D3: LED_green; D_0603_1608Metric
R23, R24, R25: 10k; R_0402_1005Metric
U5: BH1792GLC; PQFN70P280X280X100-10N

Connections:
+3V3: C7.1, D1.2 (A), D2.2 (A), D3.2 (A), R23.1, R24.1, R25.1, U5.1 (VCC); also elsewhere on the board
/BVP_INT: R25.2, U5.6 (INT); also elsewhere on the board
/SCL: R23.2, U5.10 (SCL); also elsewhere on the board
/SDA: R24.2, U5.9 (SDA); also elsewhere on the board
GND: C7.2, U5.2 (GND), U5.7 (TEST); also elsewhere on the board
unnamed: D1.1 (K), U5.5 (LED3)
unnamed: D2.1 (K), U5.4 (LED2)
unnamed: D3.1 (K), U5.3 (LED1)

Parts:
C9, C10: 100nF; C_0402_1005Metric
Rpu1, Rpu2: 10kOhms; R_0402_1005Metric
U6: LSM6DSLTR; PQFN50P300X250X86-14N

Connections:
+3V3: C9.1, C10.1, Rpu1.2, Rpu2.1, U6.5 (VDDIO), U6.8 (VDD), U6.12 (CS); also elsewhere on the board
/IMU_INT1: U6.9 (INT2); also elsewhere on the board
/IMU_INT2: U6.4 (INT1); also elsewhere on the board
/SCL: Rpu1.1, U6.13 (SCL); also elsewhere on the board
/SDA: Rpu2.2, U6.14 (SDA); also elsewhere on the board
GND: C9.2, C10.2, U6.1 (SDO/SA0), U6.6 (GND), U6.7 (GND); also elsewhere on the board

Parts:
C18, C19, C29, C30: 12p; C_0402_1005Metric
C20: 1u; C_0402_1005Metric
D4: SML-LX0404SIUPGUSB; DIOC0404X01-4N
J7: Conn_02x05_Odd_Even; PinHeader_2x05_P1.27mm_Vertical
J27: MOLEX_51281-0594MOLEX_51281-0594_0_0; Molex - 51281-0594-MOLEX_51281-0594_0
J28, J29: Conn_01x01_Male; PinHeader_1x01_P1.27mm_Vertical
R32, R33: 10k; R_0402_1005Metric
R34: 6.6k; R_0402_1005Metric
U10: AT24CS02-XHM; TSSOP-8_4.4x3mm_P0.65mm
U11: BT832L; BT832-BT832L
Y1: ABS06-32.768KHZ-T; XTAL_ABS06-32.768KHZ-T

Connections:
+3V3: C20.2, J7.1, R32.1, R33.1, R34.1, U10.8 (VCC), U11.P$9 (VDD); also elsewhere on the board
/BAT_CHRG: U11.P$C1 (C1/P24); also elsewhere on the board
/BVP_INT: U11.P$C4 (C4/P15); also elsewhere on the board
/DIS_SW: U11.P$B5 (B5/P08); also elsewhere on the board
/IMU_INT1: U11.P$B3 (B3/P31); also elsewhere on the board
/IMU_INT2: U11.P$B4 (B4/P06); also elsewhere on the board
/OXY_INT: U11.P$C3 (C3/P17)
/SCL: U11.P$B1 (B1/P25); also elsewhere on the board
/SDA: U11.P$B2 (B2/P30); also elsewhere on the board
/SoC/CSB: U11.P$A4 (A4/P05); also elsewhere on the board
/SoC/GPIO4: U11.P$C2 (C2/P22)
/SoC/P18: D4.3, J7.6, U11.P$12 (P18)
/SoC/P21: J7.10, U11.P$14 (P21/RESET)
/SoC/SCLK: U11.P$A1 (A1/P28); also elsewhere on the board
/SoC/SDI: U11.P$A3 (A3/P04); also elsewhere on the board
/SoC/SDO: U11.P$A2 (A2/P29); also elsewhere on the board
/SoC/SWCLK: J7.4, U11.P$15 (SWCLK)
/SoC/SWDIO: J7.2, U11.P$16 (SWDIO)
/programmer/RX: U11.P$D5 (D5/P11); also elsewhere on the board
/programmer/TX: U11.P$C5 (C5/P12); also elsewhere on the board
GND: C18.2, C19.2, C20.1, C29.1, C30.1, J7.3, J7.5, J7.9, U10.1 (A0), U10.2 (A1), U10.3 (A2), U10.4 (GND), U10.7 (WP), U11.P$10 (GND), U11.P$A0 (A0/VSS1), U11.P$B0 (B0/VSS2), U11.P$C0 (C0/VSS3), U11.P$D0 (D0/VSS4); also elsewhere on the board
unnamed: C18.1, U11.P$3 (P00/XL1), Y1.1
unnamed: C19.1, U11.P$4 (P01/XL2), Y1.2
unnamed: C29.2, J27.4, J29.1, U11.P$8 (P10)
unnamed: C30.2, J27.2, J28.1, U11.P$7 (P09)
unnamed: D4.1, R34.2
unnamed: D4.2, U11.P$11 (P13)
unnamed: D4.4, U11.P$13 (P20)
unnamed: R32.2, U10.5 (SDA), U11.P$1 (P26/SDA)
unnamed: R33.2, U10.6 (SCL), U11.P$2 (P27/SCL)

Parts:
C21, C23: 1u; C_0402_1005Metric
C22: 0.1u; C_0402_1005Metric
U12: CP2102N-A01-GQFN24; QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm

Connections:
+3V3: C23.1, U12.5 (VIO); also elsewhere on the board
/power/USB_VBUS: C21.1, U12.7 (REGIN), U12.8 (VBUS); also elsewhere on the board
/programmer/D+: U12.3 (D+); also elsewhere on the board
/programmer/D-: U12.4 (D-); also elsewhere on the board
/programmer/RX: U12.20 (RXD); also elsewhere on the board
/programmer/TX: U12.21 (TXD); also elsewhere on the board
GND: C21.2, C22.2, C23.2, U12.2 (GND), U12.25 (GND); also elsewhere on the board
unnamed: C22.1, U12.9 (~RSTb)

Parts:
C11, C13: 0.1u; C_0402_1005Metric
C12, C16: 4.7u; C_0402_1005Metric
C14: 5600p; C_0402_1005Metric
C15: 10u; C_0402_1005Metric
C17, C27: 22u; C_0603_1608Metric
C26: 1u; C_0402_1005Metric
D5: LED-LT PWSG-AABB-36-46-F; LED_PLCC-2
D6, D8: VEMD5010X01
D7: LED_LY_P47F-TM; LED_PLCC-2
L2: 4.7u; L_0603_1608Metric
R26, R27, R28, R29, R30: 50k; R_0402_1005Metric
R31: 4.75k; R_0402_1005Metric
R36: 0; R_0603_1608Metric
U7: TXB0104RUT; Texas_R_PUQFN-N12
U8: MAX1921EUT18+; MAX1921EUT18&plus_T
U9: MAX86141ENP+; MAX86141ENP

Connections:
+3V3: C12.1, C13.1, C17.1, C27.1, D5.2 (A), D7.2 (A), R27.2, R28.2, R29.2, R30.2, U7.11 (VCCB), U8.1 (IN), U8.3 (SHDN), U9.A1 (VLED); also elsewhere on the board
/MaxSensorComplete/1.8V: C11.1, C14.2, C26.1, R31.2, U7.1 (VCCA), U8.4 (OUT), U9.C2 (VDD_DIG), U9.D2 (VDD_ANA)
/MaxSensorComplete/CSB: U7.5 (A4), U9.A5 (CSB)
/MaxSensorComplete/SCLK: U7.2 (A1), U9.A2 (SCLK)
/MaxSensorComplete/SDI: U7.4 (A3), U9.A4 (SDI)
/MaxSensorComplete/SDO: U7.3 (A2), U9.A3 (SDO)
/SoC/CSB: R30.1, U7.7 (B4); also elsewhere on the board
/SoC/SCLK: R27.1, U7.10 (B1); also elsewhere on the board
/SoC/SDI: R29.1, U7.8 (B3); also elsewhere on the board
/SoC/SDO: R28.1, U7.9 (B2); also elsewhere on the board
GND: C11.2, C12.2, C13.2, C15.2, C16.1, C17.2, C26.2, C27.2, R26.1, R36.2, U7.6 (GND), U8.2 (AGND), U8.5 (PGND), U9.C3 (GND_DIG), U9.C4 (GND_ANA), U9.D3 (PGND); also elsewhere on the board
unnamed: C14.1, C16.2, L2.2
unnamed: C15.1, U9.B5 (VREF)
unnamed: D5.1 (K), U9.D1 (LED1_DRV)
unnamed: D6.1 (C), D6.2 (C), U9.D5 (PD1_IN)
unnamed: D6.3 (NC), D6.4 (A), D8.3 (NC), D8.4 (A), R36.1, U9.C5 (PD_GND)
unnamed: D7.1 (K), U9.C1 (LED2_DRV)
unnamed: D8.1 (C), D8.2 (C), U9.D4 (PD2_IN)
unnamed: L2.1, R31.1, U8.6 (LX)
unnamed: R26.2, U7.12 (OE)

Notes on the sheet:
PD_GND
Ground line should be routerd separately to the connector ground

Board: 2 copper layers, 62.4 x 34.1 mm, 124 parts (18 on the bottom side), 76 nets.

File Bill of Materials.xlsx (part):

Designator | Package | Quantity | Designation | Model Number | Supplier | College Discount? | Unit Price (inc VAT) | Unit Price (exc VAT) | Total Quantity with Discount applied (exc VAT) | Scaled Unit Price (inc VAT) | Scaled with Total Quantity and Discounts
C12,C16,C6 | C_0402_1005Metric | 3 | 4.7uF | C1005X5R0J475M050BC | Farnell | 0.19 | 0.19600000000000001 | 0.15680000000000002 | 0.38102400000000008 | 2.6700000000000002E-2 | 6.4881000000000008E-2
C14 | C_0402_1005Metric | 1 | 5600pF | MC0402B562K160CT | Farnell | 0.19 | 8.9999999999999993E-3 | 7.1999999999999998E-3 | 5.8320000000000004E-3 | 3.3E-3 | 2.673E-3
C15,C2,C3 | C_0402_1005Metric | 3 | 10uF | GRM155R60J106ME44D | Farnell | 0.19 | 0.83199999999999996 | 0.66559999999999997 | 1.617408 | 7.5700000000000003E-2 | 0.18395100000000003
C17,C27 | C_0603_1608Metric | 2 | 22uF | GRM188R61A226ME15D | Farnell | 0.19 | 0.23 | 0.18400000000000002 | 0.29808000000000007 | 4.3299999999999998E-2 | 7.0146E-2
C22,C13,C11, C10, C9, C1 | C_0402_1005Metric | 6 | 0.1uF | 0402YC104KAT2A | Farnell | 0.19 | 4.0399999999999998E-2 | 3.2320000000000002E-2 | 0.15707520000000003 | 6.1000000000000004E-3 | 2.9646000000000002E-2
C29,C30,C18,C19 | C_0402_1005Metric | 4 | 12pF | MC0402N120J500CT | Farnell | 0.19 | 2.0899999999999998E-2 | 1.6719999999999999E-2 | 5.41728E-2 | 3.3E-3 | 1.0692E-2
C4 | C_0402_1005Metric | 1 | 10nF | 04023C103KAT2A | Farnell | 0.19 | 3.5200000000000002E-2 | 2.8160000000000004E-2 | 2.2809600000000006E-2 | 5.1000000000000004E-3 | 4.131000000000001E-3
C7,C20,C21,C23,C26,C8,C28,C24,C25,C5 | C_0402_1005Metric | 10 | 1uF | 0402ZD105KAT2A | Farnell | 0.19 | 0.184 | 0.1472 | 1.19232 | 4.2299999999999997E-2 | 0.34262999999999999
D1 | D_0603_1608Metric | 1 | LED_ir | TAN1111C | RS | 0.19 | 0.1 | 8.0000000000000016E-2 | 6.480000000000001E-2 | 5.6799999999999996E-2 | 4.6008E-2
D2,D3 | D_0603_1608Metric | 2 | LED_green | 404-1005-1-ND | DigiKey | 0 | 0.64 | 0.51200000000000001 | 1.024 | 7.8E-2 | 0.156
D4 | DIOC0404X01-4N | 1 | SML-LX0404SIUPGUSB | SML-LX0404SIUPGUSB | Mouser | 0 | 0.78500000000000003 | 0.62800000000000011 | 0.62800000000000011 | 0.23100000000000001 | 0.23100000000000001
D5 | LED_PLCC-2 | 1 | LED-LT PWSG-AABB-36-46-F | VAOL-S2YP4 | Mouser | 0 | 0.41899999999999998 | 0.3352 | 0.3352 | 0.129 | 0.129
D7 | LED_PLCC-2 | 1 | LED_LY_P47F-TM | LT T66G-BBDA-29-0-20-R33-Z | DigiKey | 0 | 0.47 | 0.376 | 0.376 | 0.16 | 0.16
D8,D6 | VEMD5010X01 | 2 | VEMD5010X01 | VEMD5010X01 | RS | 0.19 | 0.52 | 0.41600000000000004 | 0.67392000000000007 | 0.30640000000000001 | 0.49636800000000003
FB1 | L_0402_1005Metric | 1 | Ferrite_Bead | MPZ1005A331ETD25 | Mouser | 0 | 0.183 | 0.1464 | 0.1464 | 4.8000000000000001E-2 | 4.8000000000000001E-2
J27 | Molex - 51281-0594-MOLEX_51281-0594_0 | 1 | 51281-0594 | 51281-0594 | Farnell | 0.19 | 0.31 | 0.248 | 0.20088 | 0.16 | 0.12960000000000002
J6 | USB_C_Receptacle_Amphenol_12401610E4-2A | 1 | USB_C_Receptacle_USB2.0 | 12401610E4#2A | Mouser | 0 | 1.64 | 1.3120000000000001 | 1.3120000000000001 | 0.93500000000000005 | 0.93500000000000005
L1 | L_0805_2012Metric | 1 | 22uH | MLZ2012M220WT000 | Mouser | 0 | 0.107 | 8.5600000000000009E-2 | 8.5600000000000009E-2 | 2.8000000000000001E-2 | 2.8000000000000001E-2
L2 | L_0603_1608Metric | 1 | 4.7uH | KLZ1608MHR4R7WTD25 | Mouser | 0 | 0.19 | 0.15200000000000002 | 0.15200000000000002 | 5.3999999999999999E-2 | 5.3999999999999999E-2
R13,R12 | R_0402_1005Metric | 2 | 4.99MΩ | CRCW04024M99FKEDC | Mouser | 0 | 0.1 | 8.0000000000000016E-2 | 0.16000000000000003 | 3.0000000000000001E-3 | 6.0000000000000001E-3
R14 | R_0402_1005Metric | 1 | 3.01MΩ | CRCW04023M01FKED | Farnell | 0.19 | 9.1000000000000004E-3 | 7.2800000000000009E-3 | 5.8968000000000015E-3 | 2E-3 | 1.6200000000000001E-3
R15 | R_0402_1005Metric | 1 | 6.98MΩ | CRCW04026M98FKED | Mouser | 0 | 7.5999999999999998E-2 | 6.08E-2 | 6.08E-2 | 3.0000000000000001E-3 | 3.0000000000000001E-3
R18 | R_0402_1005Metric | 1 | 1.07MΩ | RC0402FR-071M07L | Mouser | 0 | 7.5999999999999998E-2 | 6.08E-2 | 6.08E-2 | 3.0000000000000001E-3 | 3.0000000000000001E-3
R19,R16 | R_0402_1005Metric | 2 | 3.32MΩ | CRCW04023M32FKED | Mouser | 0 | 7.1999999999999995E-2 | 5.7599999999999998E-2 | 0.1152 | 3.0000000000000001E-3 | 6.0000000000000001E-3
R2 | R_0402_1005Metric | 1 | 56kΩ | CRCW04023M32FKED | Farnell | 0.19 | 7.5999999999999998E-2 | 6.08E-2 | 4.9248E-2 | 3.0000000000000001E-3 | 2.4300000000000003E-3
R20 | R_0402_1005Metric | 1 | 2.4kΩ | CRCW04022K40FKED | Farnell | 0.19 | 1.6799999999999999E-2 | 1.3440000000000001E-2 | 1.0886400000000001E-2 | 3.5000000000000001E-3 | 2.8350000000000003E-3
R21,R17 | R_0402_1005Metric | 2 | 6.65MΩ | CRCW04026M65FKED | Farnell | 0.19 | 1.1900000000000001E-2 | 9.5200000000000007E-3 | 1.5422400000000003E-2 | 3.3E-3 | 5.3460000000000001E-3
R22 | R_0402_1005Metric | 1 | 412kΩ | CRCW0402412KFKED | Farnell | 0.19 | 1.66E-2 | 1.328E-2 | 1.07568E-2 | 3.5000000000000001E-3 | 2.8350000000000003E-3
R26,R27,R29,R30,R28 | R_0402_1005Metric | 5 | 50kΩ | CRCW040250K0FKED | Mouser | 0 | 0.41899999999999998 | 0.3352 | 1.6759999999999999 | 8.1000000000000003E-2 | 0.40500000000000003
R3,R1 | R_0402_1005Metric | 2 | 4MΩ | CRCW04023M92FKED | Mouser | 0 | 7.5999999999999998E-2 | 6.08E-2 | 0.1216 | 3.0000000000000001E-3 | 6.0000000000000001E-3
R31 | R_0402_1005Metric | 1 | 4.75kΩ | CRCW04024K75FKED | Farnell | 0.19 | 8.8999999999999999E-3 | 7.1200000000000005E-3 | 5.767200000000001E-3 | 4.4000000000000003E-3 | 3.5640000000000003E-3
R33,R24,R25,R32,R23,R35,R11,R10,R9, Rpu1, Rpu2 | R_0402_1005Metric | 11 | 10kΩ | CRCW040210K0FKEDHP | Farnell | 0.19 | 4.1799999999999997E-2 | 3.3439999999999998E-2 | 0.29795039999999995 | 9.9000000000000008E-3 | 8.820900000000001E-2
R34 | R_0402_1005Metric | 1 | 6.65kΩ | MCWR04X6651FTL | Farnell | 0.19 | 4.1000000000000003E-3 | 3.2800000000000004E-3 | 2.6568000000000004E-3 | 5.9999999999999995E-4 | 4.86E-4
R4 | R_0402_1005Metric | 1 | 6.49MΩ | RC0402FR-076M49L | Mouser | 0 | 7.5999999999999998E-2 | 6.08E-2 | 6.08E-2 | 2E-3 | 2E-3
R5 | R_0402_1005Metric | 1 | 3.57M | CRCW04023M57FKED | Farnell | 0.19 | 8.8000000000000005E-3 | 7.0400000000000011E-3 | 5.7024000000000016E-3 | 2.7000000000000001E-3 | 2.1870000000000001E-3
R6 | R_0402_1005Metric | 1 | 1MΩ | MCMR04X1004FTL | Farnell | 0.19 | 8.5000000000000006E-3 | 6.8000000000000005E-3 | 5.5080000000000007E-3 | 1.2999999999999999E-3 | 1.0530000000000001E-3
R7 | R_0402_1005Metric | 1 | 2MΩ | CRCW04022M00FKED | Farnell | 0.19 | 1.6799999999999999E-2 | 1.3440000000000001E-2 | 1.0886400000000001E-2 | 3.5000000000000001E-3 | 2.8350000000000003E-3
R8 | R_0402_1005Metric | 1 | 3.3kΩ | CRCW04023K30FKED | Farnell | 0.19 | 1.46E-2 | 1.1680000000000001E-2 | 9.4608000000000018E-3 | 3.0999999999999999E-3 | 2.5110000000000002E-3
U1 | MAX17048G+ | 1 | MAX17048G+T10 | MAX17048G+T10 | Farnell | 0.19 | 1.91 | 1.528 | 1.2376800000000001 | 0.93400000000000005 | 0.7565400000000001
U10 | TSSOP-8_4.4x3mm_P0.65mm | 1 | AT24CS02-XHM | AT24CS02-XHM | Mouser | 0 | 0.16800000000000001 | 0.13440000000000002 | 0.13440000000000002 | 0.16500000000000001 | 0.16500000000000001
U11 | BT832-BT832L | 1 | BT832L | BT832L | Mouser | 0 | 7.26 | 5.8079999999999998 | 5.8079999999999998 | 3.89 | 3.89
U12 | QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm | 1 | CP2102N-A01-GQFN24 | CP2102N-A01-GQFN24 | Farnell | 0.19 | 1.24 | 0.99199999999999999 | 0.80352000000000001 | 0.93200000000000005 | 0.75492000000000004
U13 | ADG884BRMZ | 1 | ADG884BRMZ | ADG884BRMZ | Farnell | 0.19 | 2.48 | 1.984 | 1.60704 | 1.24 | 1.0044
U14,U4 | SOT-23-5 | 2 | LD39015M33R | LD39015M33R | Farnell | 0.19 | 0.68600000000000005 | 0.54880000000000007 | 0.88905600000000018 | 0.28100000000000003 | 0.45522000000000007
U2 | ADP5092ACPZ-1-R7 | 1 | ADP5092ACPZ-1-R7 | ADP5092ACPZ-1-R7 | Farnell | 0.19 | 2.52 | 2.016 | 1.6329600000000002 | 2.4 | 1.944
U3 | LTC4079IDD-PBF | 1 | LTC4079IDD-PBF | LTC4079IDD-PBF | Mouser | 0 | 5 | 4 | 4 | 2.54 | 2.54
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
## Commit log

2019-05-06 Initial commit with hardware
2019-05-06 Created sheet hierarchy"
2019-05-06 IMU FOOTPRINT
    IMU footprint
2019-05-06 IMU sensor
2019-05-06 MAXsensor
2019-05-09 Created Power PCB, both schematic and layout
2019-05-15 Finished PCB Draft -- waiting for review
2019-05-16 Fixed most DRC errors, remaining errors should be fine
2019-05-16 Moved test point to reduce the length of the LED lead
2019-05-16 Generated gerbers
2019-05-20 Updated PCB and generated gerbers
2019-05-20 Added nRF5_SDK repo as submodule
2019-05-22 Refactored currently existing code Finished BH1792GLC library
2019-05-22 Added some parts of LSM6DSL library
2019-05-24 added nRF5 sdk
2019-05-27 Finished BH1792GLC Code and started IMU driver
2019-05-30 added nfc
2019-05-30 added imu service
2019-06-03 added nfc to hrs_nfc
2019-06-03 hrs_nfc added hts
2019-06-03 renamed to p24 service
2019-06-03 rescue commit
2019-06-04 added oxygen characteristic
2019-06-05 poster
2019-06-07 sensor test
2019-06-07 leaflet
2019-06-08 index on master: 6e72c8c rescue commit
2019-06-10 latest design
2019-06-11 changed nfc record order
2019-06-11 advertise on nfc
2019-06-11 Working BH code and bluetooth, started FPU
2019-06-18 Create iOS_App
2019-06-18 icons
2019-06-18 Final version of the firmware code
2019-06-18 Cleaned up CAD branch
2019-06-18 Changed readme
2019-06-20 Demo firmware code
2019-06-21 Version at demo
2019-06-21 Added Android Code
2019-06-21 Changed submodule to directory
2019-06-21 iOS app code
2019-06-22 Pedometer, temperature, and raw accelerometer vals
    Pedometer, temperature, and raw accelerometer vals
2019-06-22 library for MAX86141
2019-06-22 MAX86141 library
2019-06-22 Rename MAX86141.cpp to max86141.cpp
2019-06-23 Components for boards
2019-06-23 BOM for PCBs
2019-06-23 Team Minutes
2019-06-23 Sample of Team Minutes
2019-06-27 Create Newfile
2019-06-27 Add files via upload
    Design History
2019-06-27 cleanup
2019-06-27 Create Solidworks Files
2019-06-27 Create Solidworks
2019-06-27 minor change
2019-06-27 screen record gif
2019-06-27 added team photo
2019-06-27 strap pictures
2019-06-27 wiki images
2019-06-27 Added screenshots to wiki folder
2019-10-07 showcase password protected
2019-12-03 gif pomo

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
